# Keil uVision project File_Demo.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.17.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: File_Demo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1052DVL6B\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Source
    ./: File_Demo.c Getline.c main.c retarget_stdio.c
  group Documentation
    ./: Abstract.txt
target Release (6190000::V6.19::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.17.0.0
  cpu: as above
  output: File_Demo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1052DVL6B\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:OS Interface:CMSIS-RTOS2 2.0.0, CMSIS-Compiler:STDERR:Custom 1.0.0, CMSIS-Compiler:STDIN:Custom 1.0.0, CMSIS-Compiler:STDOUT:Custom 1.0.0, CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, CMSIS Driver:MCI 1.5.0, CMSIS-Compiler:File Interface:MDK-MW File System 1.0.0, File System:CORE 6.16.6, File System:Drive:Memory Card 6.16.6, Board Support:SDK Drivers:evkbimxrt1050 xip 2.0.1, Board Support:SDK Project Template:project_template 1.0.0, Device:CMSIS:MIMXRT1052_header 1.0.0, Device:CMSIS:MIMXRT1052_system 1.0.0, Device:SDK Drivers:cache 2.0.4, Device:SDK Drivers:clock 2.4.0, Device:SDK Drivers:common 2.4.0, Device:SDK Drivers:gpio 2.0.6, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.7.3, Device:SDK Drivers:lpuart 2.7.6, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:nic301 2.0.1, Device:SDK Drivers:sdhc 2.8.2, Device:SDK Drivers:sdhc 2.8.4, Device:SDK Drivers:xip_device 2.0.3, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.1, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
