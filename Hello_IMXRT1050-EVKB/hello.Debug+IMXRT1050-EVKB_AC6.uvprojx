# Keil uVision project hello.Debug+IMXRT1050-EVKB_AC6.uvprojx, settings and files
target Debug+IMXRT1050-EVKB (6210000::V6.21::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.18.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x018000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: hello.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_BOOT_HEADER_ENABLE=1 XIP_EXTERNAL_FLASH=1
  asm define: XIP_BOOT_HEADER_ENABLE=1 XIP_EXTERNAL_FLASH=1
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: RTE/Device/MIMXRT1052DVL6B/MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Documentation
    ./: README.md
  group Application
    ./: hello.c
  group Board
    ./: main.c retarget_stdio.c
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDOUT:Custom 1.0.0, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, Board Support:SDK Drivers:evkbimxrt1050 xip 2.0.1, Board Support:SDK Project Template:project_template 1.0.0, Device:CMSIS:MIMXRT1052_header 1.0.0, Device:CMSIS:MIMXRT1052_system 1.0.0, Device:SDK Drivers:clock 2.4.0, Device:SDK Drivers:common 2.4.0, Device:SDK Drivers:gpio 2.0.6, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.7.6, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:nic301 2.0.1, Device:SDK Drivers:xip_device 2.0.3, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.1, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0
