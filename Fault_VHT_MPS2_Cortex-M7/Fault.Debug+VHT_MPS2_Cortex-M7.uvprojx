# Keil uVision project Fault.Debug+VHT_MPS2_Cortex-M7.uvprojx, settings and files
target Debug+VHT_MPS2_Cortex-M7 (6210000::V6.21::ARMCLANG)
  device: CMSDK_CM7_SP_VHT ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Fault.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: RTE/Device/CMSDK_CM7_SP_VHT/ac6_arm.sct
  link misc: --entry=Reset_Handler --info summarysizes
  group Documentation
    ./: README.md
  group Source Files
    ./: Fault.c ARM_FaultTrigger.c retarget_stdio.c
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDIN:Custom 1.0.0, CMSIS-Compiler:STDOUT:Custom 1.0.0, CMSIS-View:Event Recorder 1.5.3, CMSIS-View:Fault:Record 1.0.0, CMSIS-View:Fault:Storage 1.0.1, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, Board Support:Common 2.0.0, CMSIS Driver:USART 1.0.3, Device:Startup 1.1.0
